# Repository jtlemon/drill_controller (continued)

## KiCad design mega_shield/mega_shield.kicad_pcb

Board: 4 copper layers, 247.8 x 179.8 mm, 389 parts (0 on the bottom side), 232 nets.

Parts:
C1, C2, C3, C4, C9, C12, C13, C14, C15, C16, C17: 100n/50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C6, C7, C10, C11, C41, C42, C45, C46: 1u/50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C37, C38, C39, C40, C43, C44: 10u/50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C35, C36: 220u; CP_Radial_D8.0mm_P2.50mm
D1: SD24C-01F; D_SOD-323
D2, D3, D4, D5: SM4007PL; D_SOD-123F
F1, F2, F3, F4, F5, F9: SMD1812P050TF; Fuse_1812_4532Metric
F6, F7, F8: SMD1812P110TF/33; Fuse_1812_4532Metric
F10, F11: SMD1812P030TF; Fuse_1812_4532Metric
F12, F13, F14, F15: SMD1812P200TF/30; Fuse_1812_4532Metric
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11, H12, H13, H14: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad
J1, J2, J3, J5, J6: Conn_01x08_Pin; PinHeader_1x08_P2.54mm_Vertical
J4: Conn_02x18_Odd_Even; PinHeader_2x18_P2.54mm_Vertical
J7: Conn_01x10_Pin; PinHeader_1x10_P2.54mm_Vertical
J9, J10, J12, J13, J14: T4141012081-000; TE_T4141012081-000
J11: 1757271; PHOENIX_1757271
J15: T4141012121-000; TE_T4141012121-000
J16, J17, J18, J19, J20, J21, J23, J25, J26, J27, J30: 54-00277; TENSILITY_54-00277
J22: B2B-XH-A; JST_B2B-XH-A
J24: XT30PW-M; AMASS_XT30PW-M
J28, J29, J31, J32, J33, J34: 1803277; PHOENIX_1803277
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9: KT-0603R; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
NT1: NetTie_2; NetTie-2_THT_Pad1.0mm
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q20, Q21, Q22: 2N7002; SOT-23
Q23: AOD407; TO-252-2
Q24, Q27, Q30, Q32: SS8050; SOT-23
Q25, Q28, Q31, Q33: SS8550; SOT-23
Q26, Q29, Q34, Q35: AO4486; SOP-8_3.76x4.96mm_P1.27mm
R1, R6, R17, R22, R27, R32, R33: 2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3, R4, R5, R7, R8, R9, R10, R13, R14, R18, R19, R20, R21, R23, R24, R25, R26, R28, R29, R30, R31, R68, R73, R81, R82: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11, R12: 75k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15, R16: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R46, R47, R50, R51, R54, R55, R61, R62, R63, R64, R69, R70, R76, R83, R84: 4k7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R44, R45, R48, R49, R52, R53, R59, R60, R66, R67, R75, R79, R80: 2k7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R56: 0; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R57: 1M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R58: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R65, R72, R77, R78: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R71, R74: 1k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP1, TP2, TP3, TP4, TP5, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP27, TP28, TP29, TP30, TP31, TP32, TP38, TP39, TP40, TP41, TP42, TP50, TP51, TP52, TP53, TP54, TP55, TP56, TP64, TP65, TP66, TP67, TP68, TP69, TP70, TP78, TP79, TP83, TP84, TP88, TP89, TP93, TP94, TP98, TP99, TP103, TP104, TP108, TP111, TP113, TP114: 5000; KEYSTONE_5000
TP6, TP7, TP20, TP21, TP43, TP44, TP57, TP58, TP71, TP72, TP80, TP81, TP82, TP85, TP86, TP87, TP90, TP91, TP92, TP95, TP96, TP97, TP100, TP101, TP102, TP106, TP107, TP109, TP110, TP115, TP116: 5002; KEYSTONE_5002
TP8, TP22, TP33, TP45, TP59, TP73, TP105, TP112: 5001; KEYSTONE_5001
TP9, TP10, TP11, TP12, TP23, TP24, TP25, TP26, TP46, TP47, TP48, TP49, TP60, TP61, TP62, TP63, TP74, TP75, TP76, TP77: 5117; KEYSTONE_5117
TP34, TP35, TP36, TP37: 5004; KEYSTONE_5004
U1, U2, U6, U7, U8: PI162M31; SOIC-16_3.9x9.9mm_P1.27mm
U3: LMV321; SOT-23-5
U4, U9, U10, U11, U12, U13, U24: NUP2202; SOT-363_SC-70-6
U5, U29: ADuM1200; SOIC-8_3.9x4.9mm_P1.27mm
U14, U15, U16, U17, U18, U19, U22, U23, U25, U26, U30, U31: PC817; DIP-4_W7.62mm
U20: CH213K; SOT-23-3
U21: DZDH0401DW-7; SOIC6_DZDH0401DW-7_DIO
U27: 4N35; DIP-6_W7.62mm
U28: L78L05_SOT89; SOT-89-3

Connections:
+5V: C10.1, C11.2, C35.1, C41.2, C42.2, C45.1, F1.1, F2.1, F3.1, F4.1, F5.1, F9.1, LED1.2 (A), LED2.2 (A), LED3.2 (A), LED4.2 (A), LED5.2 (A), LED7.2 (A), Q24.3 (C), Q27.3 (C), R56.2, R83.1, R84.1, TP29.1 (1_1), U5.1 (VDD1), U5.8 (VDD2), U14.4, U15.4, U16.4, U17.4, U18.4, U19.4, U20.2 (VO-), U22.4, U23.4, U24.5, U25.4, U26.4, U27.5, U29.1 (VDD1)
+24V: C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C36.1, C37.1, C38.1, C39.1, C40.1, F6.1, F7.1, F8.1, F10.1, F11.1, F12.1, F13.1, F14.1, F15.1, J16.1, J17.1, J18.1, J19.1, J20.1, J21.1, J23.1, J25.1, J26.1, J27.1, LED6.2 (A), NT1.1, Q23.3 (S), Q30.3 (C), Q32.3 (C), TP80.1 (1_1), TP85.1 (1_1), TP90.1 (1_1), TP95.1 (1_1), TP100.1 (1_1), U21.4 (SOURCE), U28.3 (IN)
/digital_gpi/24V_digital_input1: J31.01, R79.2, TP109.1 (1_1)
/digital_gpi/24V_digital_input2: J32.01, R80.2, TP110.1 (1_1)
/digital_gpi/digital_input1: J4.5 (D25), R83.2, TP113.1 (1_1), U30.4
/digital_gpi/digital_input2: J4.7 (D27), R84.2, TP114.1 (1_1), U31.4
/digital_gpo/+5V_LDO: C46.2, TP111.1 (1_1), U28.1 (OUT), U29.8 (VDD2)
/digital_gpo/digital_out1: J4.4 (D22), U29.2 (Vin_a)
/digital_gpo/digital_out2: J4.3 (D23), U29.3 (Vin_a)
/digital_gpo/driver_input_A: Q30.1 (B), Q31.1 (B), R77.1, U29.7 (Vout_b)
/digital_gpo/driver_input_B: Q32.1 (B), Q33.1 (B), R78.1, U29.6 (Vout_a)
/digital_gpo/vgate_A: Q34.4, R81.2, TP115.1 (1_1)
/digital_gpo/vgate_B: Q35.4, R82.2, TP116.1 (1_1)
/homing_interface_A/LIM_MAX: J4.22 (D40), R62.1, TP99.1 (1_1), U23.3
/homing_interface_A/LIM_MAX_IN: J23.4, R60.2, TP97.1 (1_1)
/homing_interface_A/LIM_MIN: J4.24 (D42), R61.1, TP98.1 (1_1), U22.3
/homing_interface_A/LIM_MIN_IN: J25.4, R59.2, TP96.1 (1_1)
/homing_interface_B/LIM_MAX: J2.6 (A5/D59), R70.1, TP104.1 (1_1), U26.3
/homing_interface_B/LIM_MAX_IN: J26.4, R67.2, TP102.1 (1_1)
/homing_interface_B/LIM_MIN: J4.26 (D44), R69.1, TP103.1 (1_1), U25.3
/homing_interface_B/LIM_MIN_IN: J27.4, R66.2, TP101.1 (1_1)
/homing_interface_X/LIM_MAX: J6.6 (D2), R47.1, TP84.1 (1_1), U15.3
/homing_interface_X/LIM_MAX_IN: J16.4, R45.2, TP82.1 (1_1)
/homing_interface_X/LIM_MIN: J6.5 (D3), R46.1, TP83.1 (1_1), U14.3
/homing_interface_X/LIM_MIN_IN: J17.4, R44.2, TP81.1 (1_1)
/homing_interface_Y/LIM_MAX: J5.2 (D15), R51.1, TP89.1 (1_1), U17.3
/homing_interface_Y/LIM_MAX_IN: J18.4, R49.2, TP87.1 (1_1)
/homing_interface_Y/LIM_MIN: J5.1 (D14), R50.1, TP88.1 (1_1), U16.3
/homing_interface_Y/LIM_MIN_IN: J19.4, R48.2, TP86.1 (1_1)
/homing_interface_Z/LIM_MAX: J4.14 (D32), R55.1, TP94.1 (1_1), U19.3
/homing_interface_Z/LIM_MAX_IN: J20.4, R53.2, TP92.1 (1_1)
/homing_interface_Z/LIM_MIN: J5.5 (D18), R54.1, TP93.1 (1_1), U18.3
/homing_interface_Z/LIM_MIN_IN: J21.4, R52.2, TP91.1 (1_1)
/local_solenoid_drivers/SLND_11: J4.25 (D45), R63.2, U24.6
/local_solenoid_drivers/SLND_12: J4.27 (D47), R64.2, U24.1
/local_solenoid_drivers/SLND_OUT_11: Q24.1 (B), Q25.1 (B), R63.1, R65.1
/local_solenoid_drivers/SLND_OUT_12: Q27.1 (B), Q28.1 (B), R64.1, R72.1
/local_solenoid_drivers/solenoid11_N: D2.2 (A), J28.02, Q26.5, Q26.6, Q26.7, Q26.8, R71.1
/local_solenoid_drivers/solenoid11_P: D2.1 (K), F10.2, J28.01, LED8.2 (A)
/local_solenoid_drivers/solenoid12_N: D3.2 (A), J29.02, Q29.5, Q29.6, Q29.7, Q29.8, R74.1
/local_solenoid_drivers/solenoid12_P: D3.1 (K), F11.2, J29.01, LED9.2 (A)
/mega_connector/+5V_Mega: J1.5 (+5V), J4.1 (+5V), J4.2 (+5V)
/mega_connector/A_DIR: J4.10 (D28), TP54.1 (1_1), U7.3 (vin_b)
/mega_connector/A_EN: J4.6 (D24), TP55.1 (1_1), U7.4 (vin_c)
/mega_connector/A_ERR: J7.7 (D11), TP65.1 (1_1), U7.7 (vout_f)
/mega_connector/A_PED: J4.32 (D50), TP64.1 (1_1), U7.6 (vout_e)
/mega_connector/A_STEP: J4.8 (D26), TP53.1 (1_1), U7.2 (vin_a)
/mega_connector/B_DIR: J4.16 (D34), TP68.1 (1_1), U8.3 (vin_b)
/mega_connector/B_EN: J4.12 (D30), TP69.1 (1_1), U8.4 (vin_c)
/mega_connector/B_ERR: J7.6 (D12), TP79.1 (1_1), U8.7 (vout_f)
/mega_connector/B_PED: J4.34 (D52), TP78.1 (1_1), U8.6 (vout_e)
/mega_connector/B_STEP: J4.18 (D36), TP67.1 (1_1), U8.2 (vin_a)
/mega_connector/OUT_1: J4.17 (D37), R34.2, U9.6
/mega_connector/OUT_2: J6.2 (D6), R35.2, U9.1
/mega_connector/OUT_3: J4.15 (D35), R36.2, U10.6
/mega_connector/OUT_4: J6.1 (D7), R37.2, U10.1
/mega_connector/OUT_5: J5.3 (D16), R38.2, U11.6
/mega_connector/OUT_6: J5.4 (D17), R39.2, U11.1
/mega_connector/OUT_7: J4.19 (D39), R40.2, U12.6
/mega_connector/OUT_8: J4.13 (D33), R41.2, U12.1
/mega_connector/OUT_9: J4.21 (D41), R42.2, U13.6
/mega_connector/OUT_10: J4.23 (D43), R43.2, U13.1
/mega_connector/PROBE: J3.8 (A15/D69), R76.1, TP108.1 (1_1), U27.4
/mega_connector/SPIN_DIR: J6.3 (D5), TP31.1 (1_1), U5.2 (Vin_a)
/mega_connector/SPIN_EN: J6.4 (D4), TP32.1 (1_1), U5.3 (Vin_a)
/mega_connector/SPIN_PWM: J7.10 (D8), R11.1, TP30.1 (1_1)
/mega_connector/X_DIR: J2.2 (A1/D55), TP3.1 (1_1), U1.3 (vin_b)
/mega_connector/X_EN: J4.20 (D38), TP4.1 (1_1), U1.4 (vin_c)
/mega_connector/X_ERR: J5.8 (D21), J7.1 (D21), TP14.1 (1_1), U1.7 (vout_f)
/mega_connector/X_PED: J3.6 (A13/D67), TP13.1 (1_1), U1.6 (vout_e)
/mega_connector/X_STEP: J2.1 (A0/D54), TP2.1 (1_1), U1.2 (vin_a)
/mega_connector/Y_DIR: J2.8 (A7/D61), TP17.1 (1_1), U2.3 (vin_b)
/mega_connector/Y_EN: J2.3 (A2/D56), TP18.1 (1_1), U2.4 (vin_c)
/mega_connector/Y_ERR: J5.7 (D20), J7.2 (D20), TP28.1 (1_1), U2.7 (vout_f)
/mega_connector/Y_PED: J3.7 (A14/D68), TP27.1 (1_1), U2.6 (vout_e)
/mega_connector/Y_STEP: J2.7 (A6/D60), TP16.1 (1_1), U2.2 (vin_a)
/mega_connector/Z_DIR: J4.30 (D48), TP40.1 (1_1), U6.3 (vin_b)
/mega_connector/Z_EN: J3.1 (A8/D62), TP41.1 (1_1), U6.4 (vin_c)
/mega_connector/Z_ERR: J5.6 (D19), TP51.1 (1_1), U6.7 (vout_f)
/mega_connector/Z_PED: J7.5 (D13), TP50.1 (1_1), U6.6 (vout_e)
/mega_connector/Z_STEP: J4.28 (D46), TP39.1 (1_1), U6.2 (vin_a)
/power_interface/24v_pmos_gate: Q23.2 (G), R57.1, U21.2 (REF)
/power_interface/+24V_RAW_INPUT: D1.1 (A1), J24.P, Q23.1 (D), U21.6 (DRAIN)
/probe_interface/PROBE_IN: J30.4, R75.2, TP107.1 (1_1)
/probe_interface/V_Proxy: C43.1, C44.1, J30.1, NT1.2, TP106.1 (1_1)
/servo_interface_A/+5V_Servo: C14.1, C15.2, F4.2, J13.7, R22.2, TP52.1 (1_1), U7.1 (VDD1), U7.16 (VDD2)
/servo_interface_A/ALARM_IN: J13.5, TP58.1 (1_1), U7.10 (vin_f)
/servo_interface_A/AUX_IN: TP56.1 (1_1), U7.5 (vin_d)
/servo_interface_A/AUX_OUT: J13.6, Q18.3 (D), TP63.1 (1_1)
/servo_interface_A/DIR_OUT: J13.2, Q16.3 (D), TP60.1 (1_1)
/servo_interface_A/EN_OUT: J13.3, Q17.3 (D), TP62.1 (1_1)
/servo_interface_A/PED_IN: J13.4, TP57.1 (1_1), U7.11 (vin_e)
/servo_interface_A/STEP_OUT: J13.1, Q15.3 (D), TP61.1 (1_1)
/servo_interface_B/+5V_Servo: C16.1, C17.2, F5.2, J14.7, R27.2, TP66.1 (1_1), U8.1 (VDD1), U8.16 (VDD2)
/servo_interface_B/ALARM_IN: J14.5, TP72.1 (1_1), U8.10 (vin_f)
/servo_interface_B/AUX_IN: TP70.1 (1_1), U8.5 (vin_d)
/servo_interface_B/AUX_OUT: J14.6, Q22.3 (D), TP77.1 (1_1)
/servo_interface_B/DIR_OUT: J14.2, Q20.3 (D), TP74.1 (1_1)
/servo_interface_B/EN_OUT: J14.3, Q21.3 (D), TP76.1 (1_1)
/servo_interface_B/PED_IN: J14.4, TP71.1 (1_1), U8.11 (vin_e)
/servo_interface_B/STEP_OUT: J14.1, Q19.3 (D), TP75.1 (1_1)
/servo_interface_X/+5V_Servo: C1.1, C2.2, F1.2, J9.7, R1.2, TP1.1 (1_1), U1.1 (VDD1), U1.16 (VDD2)
/servo_interface_X/ALARM_IN: J9.5, TP7.1 (1_1), U1.10 (vin_f)
/servo_interface_X/AUX_IN: TP5.1 (1_1), U1.5 (vin_d)
/servo_interface_X/AUX_OUT: J9.6, Q4.3 (D), TP12.1 (1_1)
/servo_interface_X/DIR_OUT: J9.2, Q2.3 (D), TP9.1 (1_1)
/servo_interface_X/EN_OUT: J9.3, Q3.3 (D), TP11.1 (1_1)
/servo_interface_X/PED_IN: J9.4, TP6.1 (1_1), U1.11 (vin_e)
/servo_interface_X/STEP_OUT: J9.1, Q1.3 (D), TP10.1 (1_1)
/servo_interface_Y/+5V_Servo: C3.1, C4.2, F2.2, J10.7, R6.2, TP15.1 (1_1), U2.1 (VDD1), U2.16 (VDD2)
/servo_interface_Y/ALARM_IN: J10.5, TP21.1 (1_1), U2.10 (vin_f)
/servo_interface_Y/AUX_IN: TP19.1 (1_1), U2.5 (vin_d)
/servo_interface_Y/AUX_OUT: J10.6, Q8.3 (D), TP26.1 (1_1)
/servo_interface_Y/DIR_OUT: J10.2, Q6.3 (D), TP23.1 (1_1)
/servo_interface_Y/EN_OUT: J10.3, Q7.3 (D), TP25.1 (1_1)
/servo_interface_Y/PED_IN: J10.4, TP20.1 (1_1), U2.11 (vin_e)
/servo_interface_Y/STEP_OUT: J10.1, Q5.3 (D), TP24.1 (1_1)
/servo_interface_Z/+5V_Servo: C12.1, C13.2, F3.2, J12.7, R17.2, TP38.1 (1_1), U6.1 (VDD1), U6.16 (VDD2)
/servo_interface_Z/ALARM_IN: J12.5, TP44.1 (1_1), U6.10 (vin_f)
/servo_interface_Z/AUX_IN: TP42.1 (1_1), U6.5 (vin_d)
/servo_interface_Z/AUX_OUT: J12.6, Q14.3 (D), TP49.1 (1_1)
/servo_interface_Z/DIR_OUT: J12.2, Q12.3 (D), TP46.1 (1_1)
/servo_interface_Z/EN_OUT: J12.3, Q13.3 (D), TP48.1 (1_1)
/servo_interface_Z/PED_IN: J12.4, TP43.1 (1_1), U6.11 (vin_e)
/servo_interface_Z/STEP_OUT: J12.1, Q11.3 (D), TP47.1 (1_1)
/solenoid_interface/+5V_SOL: C18.1, F9.2, R33.2, U9.5, U10.5, U11.5, U12.5, U13.5
/solenoid_interface/+24V_SOL: F6.2, F7.2, F8.2, J15.11, R32.2
/solenoid_interface/SLND_OUT_1: J15.5, R34.1
/solenoid_interface/SLND_OUT_2: J15.4, R35.1
/solenoid_interface/SLND_OUT_3: J15.3, R36.1
/solenoid_interface/SLND_OUT_4: J15.2, R37.1
/solenoid_interface/SLND_OUT_5: J15.10, R38.1
/solenoid_interface/SLND_OUT_6: J15.1, R39.1
/solenoid_interface/SLND_OUT_7: J15.9, R40.1
/solenoid_interface/SLND_OUT_8: J15.8, R41.1
/solenoid_interface/SLND_OUT_9: J15.7, R42.1
/solenoid_interface/SLND_OUT_10: J15.6, R43.1
/spin_interface/SPIN_DIR_OC: J11.03, Q9.2 (S), R15.2, TP36.1 (1_1)
/spin_interface/SPIN_EN_OC: J11.04, Q10.2 (S), R16.2, TP37.1 (1_1)
/spin_interface/SPIN_SPEED: C6.2, C7.2, J11.02, TP35.1 (1_1), U3.3 (-), U3.4, U4.1, U4.6
/spin_interface/V_SPIN: C8.2, C9.2, J11.01, R15.1, R16.1, TP34.1 (1_1), U3.5 (V+), U4.5
GND: C1.2, C2.1, C3.2, C4.1, C5.2, C8.1, C9.1, C10.2, C11.1, C12.2, C13.1, C14.2, C15.1, C16.2, C17.1, C18.2, C35.2, C36.2, C41.1, C42.1, C43.2, C44.2, C45.2, C46.1, D1.2 (A2), H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1 (1_1), H5.1 (1_1), H6.1 (1_1), H7.1 (1_1), H8.1 (1_1), H9.1 (1_1), H10.1 (1_1), H11.1 (1_1), H12.1 (1_1), H13.1 (1_1), H14.1 (1_1), J1.6 (GND), J1.7 (GND), J4.35 (GND), J4.36 (GND), J7.4 (GND), J9.8, J10.8, J11.05, J12.8, J13.8, J14.8, J15.12, J22.1, J24.N, J30.3, J31.02, J32.02, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), Q9.3 (D), Q10.3 (D), Q11.2 (S), Q12.2 (S), Q13.2 (S), Q14.2 (S), Q15.2 (S), Q16.2 (S), Q17.2 (S), Q18.2 (S), Q19.2 (S), Q20.2 (S), Q21.2 (S), Q22.2 (S), Q25.3 (C), Q26.1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
unnamed: C6.1, C7.1, R11.2, R12.1
unnamed: C19.2, C21.2, J17.3
unnamed: C20.2, C22.2, J16.3
unnamed: C23.2, C25.2, J19.3
unnamed: C24.2, C26.2, J18.3
unnamed: C27.2, C29.2, J21.3
unnamed: C28.2, C30.2, J20.3
unnamed: C31.2, C33.2, J25.3
unnamed: C32.2, C34.2, J23.3
unnamed: C37.2, C39.2, J27.3
unnamed: C38.2, C40.2, J26.3
unnamed: D4.2 (A), J33.02, Q34.5, Q34.6, Q34.7, Q34.8
unnamed: D4.1 (K), F12.2, F13.2, J33.01
unnamed: D5.2 (A), J34.02, Q35.5, Q35.6, Q35.7, Q35.8
unnamed: D5.1 (K), F14.2, F15.2, J34.01
unnamed: LED1.1 (K), R1.1
unnamed: LED2.1 (K), R6.1
unnamed: LED3.1 (K), R17.1
unnamed: LED4.1 (K), R22.1
unnamed: LED5.1 (K), R27.1
unnamed: LED6.1 (K), R32.1
unnamed: LED7.1 (K), R33.1
unnamed: LED8.1 (K), R71.2
unnamed: LED9.1 (K), R74.2
unnamed: Q1.1 (G), R2.1
unnamed: Q2.1 (G), R3.1
unnamed: Q3.1 (G), R4.1
unnamed: Q4.1 (G), R5.1
unnamed: Q5.1 (G), R7.1
unnamed: Q6.1 (G), R8.1
unnamed: Q7.1 (G), R9.1
unnamed: Q8.1 (G), R10.1
unnamed: Q9.1 (G), R13.2
unnamed: Q10.1 (G), R14.1
unnamed: Q11.1 (G), R18.1
unnamed: Q12.1 (G), R19.1
unnamed: Q13.1 (G), R20.1
unnamed: Q14.1 (G), R21.1
unnamed: Q15.1 (G), R23.1
unnamed: Q16.1 (G), R24.1
unnamed: Q17.1 (G), R25.1
unnamed: Q18.1 (G), R26.1
unnamed: Q19.1 (G), R28.1
unnamed: Q20.1 (G), R29.1
unnamed: Q21.1 (G), R30.1
unnamed: Q22.1 (G), R31.1
unnamed: Q24.2 (E), Q25.2 (E), R68.1
unnamed: Q26.4, R68.2
unnamed: Q27.2 (E), Q28.2 (E), R73.1
unnamed: Q29.4, R73.2
unnamed: Q30.2 (E), Q31.2 (E), R81.1
unnamed: Q32.2 (E), Q33.2 (E), R82.1
unnamed: R44.1, U14.1
unnamed: R45.1, U15.1
unnamed: R48.1, U16.1
unnamed: R49.1, U17.1
unnamed: R52.1, U18.1
unnamed: R53.1, U19.1
unnamed: R59.1, U22.1
unnamed: R60.1, U23.1
unnamed: R66.1, U25.1
unnamed: R67.1, U26.1
unnamed: R75.1, U27.1
unnamed: R79.1, U30.1
unnamed: R80.1, U31.1
unnamed: R2.2, U1.15 (vout_a)
unnamed: R3.2, U1.14 (vout_b)
unnamed: R4.2, U1.13 (vout_c)
unnamed: R5.2, U1.12 (vout_d)
unnamed: R7.2, U2.15 (vout_a)
unnamed: R8.2, U2.14 (vout_b)
unnamed: R9.2, U2.13 (vout_c)
unnamed: R10.2, U2.12 (vout_d)
unnamed: C5.1, R12.2, U3.1 (+)
unnamed: R14.2, U5.6 (Vout_a)
unnamed: R13.1, U5.7 (Vout_b)
unnamed: R18.2, U6.15 (vout_a)
unnamed: R19.2, U6.14 (vout_b)
unnamed: R20.2, U6.13 (vout_c)
unnamed: R21.2, U6.12 (vout_d)
unnamed: R23.2, U7.15 (vout_a)
unnamed: R24.2, U7.14 (vout_b)
unnamed: R25.2, U7.13 (vout_c)
unnamed: R26.2, U7.12 (vout_d)
unnamed: R28.2, U8.15 (vout_a)
unnamed: R29.2, U8.14 (vout_b)
unnamed: R30.2, U8.13 (vout_c)
unnamed: R31.2, U8.12 (vout_d)
unnamed: J22.2, R56.1, U20.3 (VI+)
unnamed: R58.1, U21.3 (BIAS)

## Code that names these connections

File mega_shield/test_programs/cnc_retrofit_mega_shield_tester.ino (part):

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
//Probe Interface

#define PROBE 15 //A15

//10CH Solenoid Interface

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
//Digital Outputs

#define DIGITAL_OUT1 22 //D22
#define DIGITAL_OUT2 23 //D23k

//On-Board Solenoid Drivers

#define SLND_11 45 //D45
#define SLND_12 47 //D47

#define SOLENOID_LEN 12

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
void probe_init(void)
{
  pinMode(PROBE, INPUT);
}

bool check_probe_interface(void)
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
void digital_output_init(void)
{
  pinMode(DIGITAL_OUT1, OUTPUT);
  pinMode(DIGITAL_OUT2, OUTPUT);
}

void digital_output_tests(void)
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
void digital_output_set(uint8_t pin, bool enable)
{
  if(pin != DIGITAL_OUT1 && pin != DIGITAL_OUT2)
  {
    Serial.println("Error: digital_output_set(), invalid pin.");
  }
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
## Commit log (part)

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2025-05-05 propigated changes to the probe interface.
2025-05-06 removed now uneeded sheet pin from the gpi sheet.
2025-05-06 Added net-tie to avoid testing error with labeling.
2025-05-06 Finished running ERC(electrical rule check) on entire project.
2025-05-06 Finished adding test points to the GPO sheet.
2025-05-06 updated JLCPCB numbers and added new ones.
2025-05-06 ran update operation on the PCB components.
2025-05-06 seperated out homing interface for x-axis.
2025-05-07 replicated layout of homing interfaces. Placed the homing interface into PCB.
2025-05-07 created layout for the +5V and +24V external power input sections.
2025-05-07 deleted tracks and vias for digital outputs sheet. Re-annotated components need swapped.
2025-05-07 moved all servo interfaces outside PCB to re-factor the layout using the new components.
2025-05-07 moved all groups of servo interfaces into the PCB area.
2025-05-07 grouped and locked the digital outputs.
2025-05-07 moved polyfuse into the +5V psu section.
2025-05-07 updated checklist with new items.
2025-05-08 created layout for the 10 channel solenoid interface.
2025-05-08 adjusted power plane +24v and +5v for the solenoid interface.
2025-05-08 conneced X-axis homing interface to mega.
2025-05-08 connected Z-axis homing interface to mega. Updated silkscreen labels for homing interfaces.
2025-05-08 connected B-axis homing interface to mega.
2025-05-08 replicated x-axis servo interface accross all 5 axis.
2025-05-08 added missing trace from test point and replicated accross all servo interfaces.
2025-05-08 adjusted homing interface via to free up room.
2025-05-08 Added trace+via for led indicators.
2025-05-08 added item to checklist.
2025-05-08 routed traces for the +5V external psu.
2025-05-09 routed traces between all components for the solenoid drivers section.
2025-05-09 finished routing traces for the digital inputs, connected to the mega as well.
2025-05-09 connected solenoid channels to the mega.
2025-05-09 updated state of the checklist.
2025-05-09 Added optional electrolytic capacitor footprints for both the +5V and +24V rails.
2025-05-09 Added missing +5V connection to solenoid interface IC.
2025-05-09 fixed silkscreen clipping issue on 10ch solenoid section.
2025-05-09 moved silkscreen test point text to avoid collisions.
2025-05-09 fixed issue with shcematic connector having moved in homing interface sheet.
2025-05-09 update state of checklist.
2025-05-13 Adjusted R3 & R4 silkscreen text.
2025-05-13 set the correct axis labels for the homing interfaces on the silkscreen.
2025-05-13 adjusted j11 and j10 text for Y-axis homing interface.
2025-05-13 adjusted the j20 and j21 text for the B-axis homing interface.
2025-05-13 fixed silkscreen conflict between C29 and the R49 components.
2025-05-13 fixed silkscreen text sizing issues in the spindle interface section.
2025-05-13 Added text box for board infomation including date and revision number for the board.
2025-06-17 Added polarity, arduino pin numbers and digital output channel text to front silkscreen.
2025-06-17 Added additional labels to the spindle interface pins.
2025-06-17 Added arduino pin information for the probe and digital I/O to the front silkscreen.
2025-06-18 Finished X and Z motor pin mappings.
2025-06-18 Added motor mapping for the a-axis
2025-06-18 Added mapping x-axis homing.
2025-06-18 Added remaining homing mappings, digital inputs and outputs.
2025-06-18 Added tables for mega pin mappings of stepper and homing interface to back of PCB silkscreen.
2025-06-18 Added table for the digital outputs to back silkscreen.
2025-06-18 Adde probe pi nmapping table to back silkscreen.
2025-06-18 automatic view change.
2025-06-18 moved probe pin mapping table in Y-axis
2025-06-26 Created blank kicad project for the servo adapter board.
2025-06-26 Added servo driver transistors to schematic.
2025-06-26 Added unspeced bypass caps and resistors.
2025-06-28 Added the symbol for the M8 connectori.
2025-06-28 Added the 3D model for the 8 pin connector
2025-06-28 Added the M12 8 pin signal connector and labels for all signal pins.
2025-06-28 Added the 10pin female socket (adapter --> servo motor) and labels for each of the pins along with passive components.
2025-06-28 Added power flag to the +5v line from the mega.
2025-06-28 (servo adapter) Added 5pin connector symbol.
2025-06-28 (servo connector) Added 5pin connector 3D model.
2025-06-28 Added possible alternate part.
2025-06-28 Updated with generic 2pin symbol and labels used for the servo motor power connection.
2025-08-16 Added mounting holes and Test Points.
    Added a second mounting hole. Added test points for +48VDC, +5VDC and
    GND.
2025-08-16 Added footprints for Caps, mounting holes and 2.54mm servo connector.
2025-08-16 changed R1, R2 value from 3.48k --> 3.5k and set the 0603 footprint.
2025-08-16 Added 3D model for MUN5233
2025-08-16 Changed PCM library symbol for project specific symbol.
2025-08-16 whitespace change.
2025-08-27 updated the state of the checklist.
2025-08-27 Placed components related groups.
2025-09-05 Added extra mounting holes using 3.5mm diameter.
2025-09-05 Created edge cuts outline and rounded corners to 2mm.
2025-09-05 Added ground power plane for EMI resistance.
2025-09-05 placed and locked test points.
2025-09-05 moved both connectors onto pcb.
2025-09-05 flipped the 2.54mm connectors.
2026-01-09 Refactored the dimensions and footprints
    + Re-dimensioned the step file.
    + Relocated the 2.54mm du-pont connector/socket.
    + Changed the MH3 and MH4 to use 2.2mm holes.(closest to 2.0mm).
    + Relocated MH1 and MH2
2026-01-10 Updated with traces, ground plane and change to stackup.
    + Changed to 2-Layer board.
    + Routed traces on layer 1
    + Added some silkscreen info
2026-01-10 Added the 2pin power connector to servo adapter board and schematic.
2026-01-10 Servo adapter, added footprint, symbol and 3D model for 10 pin connector.
2026-01-10 Servo adapter, refactored new connector model and traces.
    + Re-routed the traces.
    + Chagned out the old 2.54mm connector.
    + Added copper fill for higher amprage on the +48V line.
2026-01-10 Servo adapter, ran and passed derign rules check.
2026-01-11 Servo adapter, updated state of checklist
2026-01-11 Servo adapter, added design comments / dimensions
    + Added dimensions to comments layer in pcb design.
    + Ran DRC again and confirmed passing.
2026-01-12 Solenoid_10, Updated checklist with some notes
2026-01-12 Solenoid_10, Updated text sizes on silkscreen and ran DRC
2026-01-12 Solenoid_10, checked stock of more parts update fp.
    + Checked stock of Caps, LEDs, diodes and inductors.
    + Updated Footprints for better compat accross systems.
2026-01-12 Solenoid_10, Applied text default to front/back of board, ran and fixed all DRC errors.
2026-01-12 Solenoid_10
    + Specified HAL lead-free for copper finish to prevent oxidation.
2026-01-13 mega_shield, imported the new data
    + Imported design constraints from my new 4 layer template.
2026-01-13 mega_shield, changed DS name for AO4486 fet.
2026-01-13 mega_shield, changed footprint for the led to built in 0603(IMPRL)/1608(Metric)
2026-01-13 mega_shield, updated checklist on gate protection diodes.
2026-01-13 mega_shield, Added footprint for net tie.
2026-01-14 mega_shield, added notes on test point color coding.
2026-01-14 mega_shield, added new item to checklist.
2026-01-14 mega_shield, Added 3D models for all test points/types.
2026-01-14 mega_shield, Added all test point symbols and updated association of 3D models.
2026-01-14 mega_shield, working on rebuilding homoing interface layout.
2026-01-15 mega_shield, Updated homing interfaces routed traces and zones, and replicated accross all homing interfaces.
2026-01-15 mega_shield, rerouted traces for X-axis servo interface and adjusted new footprints.
2026-01-15 mega_shield, fixed final routing of traces from MCU to servo interfaces.
2026-01-15 mega_shield, spindle interface rearranged for ESD protection.
2026-01-15 mega_shield, Created new symbol and linked footprint for WCH CH213K ideal diode IC.
2026-01-15 mega_shield, re-annotated components, routed and placed new symbols for 5V external power section.
2026-01-16 mega_shield, Updated project library table, adjusted ideal diode footprint/symbols.
2026-01-16 mega_shield, setup schematic, footprint, pad numbers, and P-Channel mosfet for rp
2026-01-16 mega_shield, Added current sense IC and Comparator along with 5m resistor for high speed programable OCP.
2026-01-16 servo_adapter, Added/found jlcpcb number for the 3.81mm 10P connector.
    The connector is very low in availble stock/quantity as it's usally not
    one that's used.
    There is a lot of them availble on LCSC however.
2026-01-16 servo_adapter, finished setting exceptions for ERC
2026-01-17 servo_adapter, fixed pin numbering.
2026-01-17 solenoid_10, refactored for manufacturing.
    + chagned cap to alternate that costs less for assembly.
    + marked more components as DNP
    + marked more components as no POS.
2026-01-17 solenoid_10, cleaned up traces to LEDs for visual consistency.
2026-01-20 mega_shield, setup INA180A2 for 50x gain accross the 5mOhm shunt. More than 10x the offset voltage of comparator for margin.
2026-01-21 solenoid_10, added note on ideas for futher improvements.
2026-01-21 mega_shield, added jlcpcb number for the P-Channel mosfet, good for 60V and 12A.
2026-01-21 mega_shield, changed out input ESD diode for SD24, also added jlcpcb number.
2026-01-21 mega_shield, re-ran annotation of entire project.
2026-01-22 mega_shield, routed traces for +24V input RP protection.
2026-01-22 mega_shield, finished laying out and routing solenoid driver section.
2026-01-22 mega_shield, added 5V voltage regulator for isolator IC. Added jlcpcb number.
2026-01-27 mega_shield, Added new values and schematic for PWM spindle interface LPF.
    + Added two pole RC low-pass filter
    + Added Op-AMP voltage follower, post filter.
2026-01-27 mega_shield, updated the calculations for the filters.
2026-01-27 mega_shield, asigned active filter footprints and jlcpcb numbers.
2026-01-28 mega_shield, re-annotated schematic's components.
2026-01-28 mega_shield, added datasheets
2026-01-28 mega_shield, chagned all homing interface sections in schematic and PCB, changed all servo connectors.
2026-01-28 mega_shield, refactored spindle interface PCB section.
2026-01-29 mega_shield, added T4140012081 model.
2026-01-29 mega_shield, changed out the J22 probe connector.
2026-01-29 mega_shield, marked circular components as DNP, added jlcpcb numbers to 90degree terminal blocks.
2026-01-30 mega_shield, re-annotated all components.
2026-01-30 mega_shield, swapped out hex channel digital isolator for all servo interfaces.
2026-01-30 mega_shield, reconfigured probe interface for new sensor selection.
2026-01-30 mega_shield, updated symbols for test points on probe interface.
2026-01-30 mega_shield, fixed issue with admum1200 footprint.
2026-01-30 mega_shield, updated state of checklist for completed tasks.
2026-01-30 mega_shield, passing all ERC(electrical rules check). Zero errors
    + Fixed missing symbols from defunct digikey lib.
    + Fixed created custom symbol for AO4486 NMOS.
    + Fixed all Power flag and pin conflicts.
    + Excluded passive/unspecified warnings/errors.
2026-01-30 mega_shield, rerouted and place components for spindle interface
2026-01-31 mega_shield, routed traces for x-axis homing interface
2026-01-31 mega_shield, routed new connections from MCU to homing interfaces(all)
2026-01-31 mega_shield, fixed net issue with Q29 and Q30
2026-01-31 mega_shield, fixed more DRC errors, down to 16
2026-01-31 mega_shield, add note on mega connector options.
