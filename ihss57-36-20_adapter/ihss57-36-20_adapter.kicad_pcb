# Repository jtlemon/drill_controller

File README.md:

# Drill Controller
This repository contains the drill controller PCB design and schematic files
for both the pneumatic breakout, motor driver board and the shield pcb.

## Pneumatic

The pneumatic breakout is designed to connect via an industrial circular 
connector, allowing power switching directly next to the solenoid valves.

The connector used is the M12 12Pin connector. Compatible connectors I've found
assuming data sheet accuracy are:

- [T4140012121-000](https://www.mouser.com/ProductDetail/TE-Connectivity/T4140012121-000?qs=l7cgNqFNU1i1rwRV8IAvtw%3D%3D)
- [M12-P12A-GPBM12](https://jlcpcb.com/partdetail/Cazn-M12_P12AGPBM12/C7423418)

## Shield

Note: Most the protection circuitry should be on the shield itself, such as
optical isolation of signals and ESD protection. Larger fuses will be located
externally for the higher voltage components.

## Servo Adapter board

The board to adapter the servo motors to use a standardized set of connectors
accross the machine.

There is two sevo adapter boards, the one for the NEMA23 and the NEMA34 
sized closed loop motors.

## KiCad design ihss57-36-20_adapter/ihss57-36-20_adapter.kicad_pcb

Parts:
C1, C2: 22uF/63v; CP_Elec_6.3x7.7; LCSC C5246567
H1, H2: MountingHole; MountingHole_3.5mm
H3, H4: MountingHole_Pad; MountingHole_2.2mm_M2_DIN965_Pad
J1: T4141012051-000; CONN5_T4141012051; LCSC C7423411
J2: T4140012081-000; TE_T4140012081-000; PARTREV B; LCSC C19171040
J3: Conn_01x10_Socket; PinSocket_1x10_P2.54mm_Vertical
J4: 1875425; PHOENIX_1875425; LCSC C5189069
J5: Conn_01x10_Socket; PinSocket_1x10_P2.54mm_Vertical; LCSC C2897373; not fitted
NT1, NT2, NT3, NT4, NT5, NT6, NT7: NetTie_2; NetTie-2_SMD_Pad0.5mm
R1, R2: 3.5k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C4310
TP1: +5V_Servo; TestPoint_Pad_1.0x1.0mm; not fitted
TP2: +48V; TestPoint_Pad_1.0x1.0mm; not fitted
TP3: GND; TestPoint_Pad_1.0x1.0mm; not fitted
U1, U2, U3: MUN5233T1G; SOT-323_SC-70; LCSC C417307
U4: MUN5233T1G; SOT-323_SC-70; LCSC C417307; not fitted

Connections:
/+5V_Servo: C1.1, J2.7, NT3.1, NT4.1, NT5.1, NT6.1, NT7.1, TP1.1 (1_1)
/+48V: C2.1, J1.1, J1.2, J4.3, J4.4, TP2.1 (1_1)
/ALARM_OUT: J2.5, NT2.1
/ALM+: J3.2, NT3.2
/ALM-: J3.1, NT2.2, R1.1
/AUX-: U4.3 (COLLECTOR)
/AUX_IN: J2.6, U4.1 (BASE)
/DIR+: J3.8, NT6.2
/DIR-: J3.7, U2.3 (COLLECTOR)
/DIR_IN: J2.2, U2.1 (BASE)
/ENA+: J3.6, NT5.2
/ENA-: J3.5, U1.3 (COLLECTOR)
/EN_IN: J2.3, U1.1 (BASE)
/PED+: J3.4, NT4.2
/PED-: J3.3, NT1.2, R2.1
/PED_OUT: J2.4, NT1.1
/PUL+: J3.10, NT7.2
/PUL-: J3.9, U3.3 (COLLECTOR)
/STEP_IN: J2.1, U3.1 (BASE)
GND: C1.2, C2.2, H3.1 (1_1), H4.1 (1_1), J1.3, J1.4, J2.8, J4.1, J4.2, R1.2, R2.2, TP3.1 (1_1), U1.2 (EMITTER), U2.2 (EMITTER), U3.2 (EMITTER), U4.2 (EMITTER)

Notes on the sheet:
48V Servo Power(Adapter --> Servo Motor)
M12 8Pin Signal Connector(From Mega Shield)
Hardware(Mounting Holes)
Net Ties
Servo Driver Transistors
Servo Driver Signals(Adapter --> Servo Motor)
Servo Power(External --> Adapter)
Test Points
Alternate numbers: C5189069, C6394088, C21409383
The 10 pin connector used on the motor looks like the 3.81mm plug connector. Here's a list of what I think are likely compatable connectors. DB2EB-3.81-10P-GN terms like KF2EDG, EDG are pretty common terms associated with them along with MCV Current assumption is that for multi motor compatability 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

Board: 2 copper layers, 50.0 x 64.0 mm, 26 parts (2 on the bottom side), 19 nets.

## KiCad design ihss86-60-45_adapter/ihss86-60-45_adapter.kicad_pcb

Parts:
C1: 22uF/63v; CP_Elec_6.3x7.7; LCSC C5246567
H1, H2, H3, H4: MountingHole; MountingHole_3.5mm
J2: T4140012081-000; TE_T4140012081-000; PARTREV B; LCSC C19171040
J5: Conn_01x10_Socket; PinSocket_1x10_P2.54mm_Vertical; LCSC C5159939
J6: Conn_01x10_Socket; PinHeader_1x10_P2.54mm_Vertical; LCSC C2897373; not fitted
NT1, NT2, NT3, NT4, NT5, NT6, NT7: NetTie_2; NetTie-2_SMD_Pad0.5mm
R3, R4: 3.5k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C4310
TP1: +5V_Servo; TestPoint_Pad_1.0x1.0mm; not fitted
TP3: GND; TestPoint_Pad_1.0x1.0mm; not fitted
U1, U2, U3: MUN5233T1G; SOT-323_SC-70; LCSC C417307
U4: MUN5233T1G; SOT-323_SC-70; LCSC C417307; not fitted

Connections:
/+5V_Servo: C1.1, J2.7, NT2.1, NT3.1, NT4.1, NT5.1, NT6.1, TP1.1 (1_1)
/ALARM_OUT: J2.5, NT7.1
/ALM+: J5.2, NT6.2
/ALM-: J5.1, NT7.2, R3.1
/AUX-: U4.3 (COLLECTOR)
/AUX_IN: J2.6, U4.1 (BASE)
/DIR+: J5.8, NT2.2
/DIR-: J5.7, U2.3 (COLLECTOR)
/DIR_IN: J2.2, U2.1 (BASE)
/ENA+: J5.6, NT4.2
/ENA-: J5.5, U1.3 (COLLECTOR)
/EN_IN: J2.3, U1.1 (BASE)
/PED+: J5.4, NT5.2
/PED-: J5.3, NT1.2, R4.1
/PED_OUT: J2.4, NT1.1
/PUL+: J5.10, NT3.2
/PUL-: J5.9, U3.3 (COLLECTOR)
/STEP_IN: J2.1, U3.1 (BASE)
GND: C1.2, J2.8, R3.2, R4.2, TP3.1 (1_1), U1.2 (EMITTER), U2.2 (EMITTER), U3.2 (EMITTER), U4.2 (EMITTER)

Notes on the sheet:
Servo Driver Signals(Adapter --> Servo Motor)
Test Points
Square female Header
Hardware(Mounting Holes)
M12 8Pin A-Coded Signal Connector(From Mega Shield)
Signal Name Net Ties
Servo Driver Transistors
Round Female Header
The 10pin connector used requires an stacking pin header to correctly make contact. To handle this issue the connection is broken into two disinct sections the round or machined 2.54mm header and the standard duPont style 2.54mm square header that fits the square servo motor pins. RoundPin Female H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
Alternate M12 8P Male part numbers: C45986647, C7423417, C45986631, C7423412, C45986635

Board: 2 copper layers, 90.0 x 40.0 mm, 22 parts (1 on the bottom side), 18 nets.

## KiCad design solenoid_10/solenoid_10.kicad_pcb

Parts:
H11, H12: 4.5mm; MountingHole_4.5mm; not fitted
J22: M12-P12A-GPBM12; TE_T4140012121-000; PARTREV B; LCSC C7423418
LED1, LED2: KT-0603R; LED_0603_1608Metric; LCSC C2286
R1, R2: 1k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Rating W; LCSC C17379
TP1: +24v; TestPoint_Pad_1.0x1.0mm; not fitted
TP2: VGATE; TestPoint_Pad_1.0x1.0mm; not fitted
TP3: CH1; TestPoint_Pad_1.0x1.0mm; not fitted
TP4: CH2; TestPoint_Pad_1.0x1.0mm; not fitted
TP5: CH3; TestPoint_Pad_1.0x1.0mm; not fitted
TP6: CH4; TestPoint_Pad_1.0x1.0mm; not fitted
TP7: CH5; TestPoint_Pad_1.0x1.0mm; not fitted
TP8: CH6; TestPoint_Pad_1.0x1.0mm; not fitted
TP9: CH7; TestPoint_Pad_1.0x1.0mm; not fitted
TP10: CH8; TestPoint_Pad_1.0x1.0mm; not fitted
TP11: CH9; TestPoint_Pad_1.0x1.0mm; not fitted
TP12: CH10; TestPoint_Pad_1.0x1.0mm; not fitted

Connections:
/+24V: J22.11, LED1.2 (A), TP1.1 (1_1); also elsewhere on the board
/CH1_IN: J22.5, TP3.1 (1_1); also elsewhere on the board
/CH2_IN: J22.4, TP4.1 (1_1); also elsewhere on the board
/CH3_IN: J22.3, TP5.1 (1_1); also elsewhere on the board
/CH4_IN: J22.2, TP6.1 (1_1); also elsewhere on the board
/CH5_IN: J22.10, TP7.1 (1_1); also elsewhere on the board
/CH6_IN: J22.1, TP8.1 (1_1); also elsewhere on the board
/CH7_IN: J22.9, TP9.1 (1_1); also elsewhere on the board
/CH8_IN: J22.8, TP10.1 (1_1); also elsewhere on the board
/CH9_IN: J22.7, TP11.1 (1_1); also elsewhere on the board
/CH10_IN: J22.6, TP12.1 (1_1); also elsewhere on the board
/VGATE: LED2.2 (A), TP2.1 (1_1); also elsewhere on the board
GND: J22.12, R1.1 (+), R2.1 (+); also elsewhere on the board
unnamed: LED1.1 (K), R1.2 (-)
unnamed: LED2.1 (K), R2.2 (-)

Notes on the sheet:
Power Indicator(VGATE)
M12 Mounting Holes
Power Indicator(24v)
5V Testing supply
M12 Connector 12 Pin
Solenoid Channels
Test Points
The Input connections should already be Opto-Isolated on the connected Shield PCB. The pin numbers and channel labels are mismatched because it's setup to optimize the layout of the PCB traces to minimize EMI and the number of vias needed.

Parts:
D1: SM4007PL; D_SOD-123F; LCSC C64898
F1: SMD1812P030TF; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder; LCSC C20995
H1: solenoid_hole; MountingHole_3.5mm; not fitted
J2, J3: 1217080-1; TE_1217080-1; PARTREV B1; not fitted
LED3: KT-0603R; LED_0603_1608Metric; LCSC C2286
Q1: AO4486; SOP-8_3.76x4.96mm_P1.27mm; LCSC C5125950
R3: 4k7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Rating W; LCSC C17673
R4: 1k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Rating W; LCSC C17379
S1: B3F-1000; Switch_Tactile_THT_B3F-1xxx; MPN B3F-1000; Digi-Key_PN SW400-ND

Connections:
/+24V: F1.1; also elsewhere on the board
/CH1_IN: R3.1 (+), S1.1, S1.2; also elsewhere on the board
/VGATE: S1.3, S1.4; also elsewhere on the board
/solenoid_channel1/solenoid_N: D1.2 (A), J3.1, J3.2, Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D), R4.1 (+)
/solenoid_channel1/solenoid_P: D1.1 (K), F1.2, J2.1, J2.2, LED3.2 (A)
GND: Q1.1 (S), Q1.2 (S), Q1.3 (S); also elsewhere on the board
unnamed: LED3.1 (K), R4.2 (-)
unnamed: Q1.4 (G), R3.2 (-)

Parts of its further copies:
D3, D4, D5, D6, D7, D8, D9, D10, D11: SM4007PL; D_SOD-123F; LCSC C64898
F3, F4, F5, F6, F7, F8, F9, F10, F11: SMD1812P030TF; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder; LCSC C20995
H2, H3, H4, H5, H6, H7, H8, H9, H10: solenoid_hole; MountingHole_3.5mm; not fitted
J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14, J15, J16, J17, J18, J19, J20, J21: 1217080-1; TE_1217080-1; PARTREV B1; not fitted
LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12: KT-0603R; LED_0603_1608Metric; LCSC C2286
Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11: AO4486; SOP-8_3.76x4.96mm_P1.27mm; LCSC C5125950
R6, R8, R10, R12, R14, R16, R18, R20, R22: 4k7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Rating W; LCSC C17673
R7, R9, R11, R13, R15, R17, R19, R21, R23: 1k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Rating W; LCSC C17379
S2, S3, S4, S5, S6, S7, S8, S9, S10: B3F-1000; Switch_Tactile_THT_B3F-1xxx; MPN B3F-1000; Digi-Key_PN SW400-ND

Connections of its further copies:
/+24V: F3.1, F4.1, F5.1, F6.1, F7.1, F8.1, F9.1, F10.1, F11.1; also elsewhere on the board
/CH2_IN: R6.1 (+), S2.1, S2.2; also elsewhere on the board
/CH3_IN: R8.1 (+), S3.1, S3.2; also elsewhere on the board
/CH4_IN: R10.1 (+), S4.1, S4.2; also elsewhere on the board
/CH5_IN: R12.1 (+), S5.1, S5.2; also elsewhere on the board
/CH6_IN: R14.1 (+), S6.1, S6.2; also elsewhere on the board
/CH7_IN: R16.1 (+), S7.1, S7.2; also elsewhere on the board
/CH8_IN: R18.1 (+), S8.1, S8.2; also elsewhere on the board
/CH9_IN: R20.1 (+), S9.1, S9.2; also elsewhere on the board
/CH10_IN: R22.1 (+), S10.1, S10.2; also elsewhere on the board
/VGATE: S2.3, S2.4, S3.3, S3.4, S4.3, S4.4, S5.3, S5.4, S6.3, S6.4, S7.3, S7.4, S8.3, S8.4, S9.3, S9.4, S10.3, S10.4; also elsewhere on the board
/solenoid_channel2/solenoid_N: D3.2 (A), J5.1, J5.2, Q3.5 (D), Q3.6 (D), Q3.7 (D), Q3.8 (D), R7.1 (+)
/solenoid_channel2/solenoid_P: D3.1 (K), F3.2, J4.1, J4.2, LED4.2 (A)
/solenoid_channel3/solenoid_N: D4.2 (A), J7.1, J7.2, Q4.5 (D), Q4.6 (D), Q4.7 (D), Q4.8 (D), R9.1 (+)
/solenoid_channel3/solenoid_P: D4.1 (K), F4.2, J6.1, J6.2, LED5.2 (A)
/solenoid_channel4/solenoid_N: D5.2 (A), J9.1, J9.2, Q5.5 (D), Q5.6 (D), Q5.7 (D), Q5.8 (D), R11.1 (+)
/solenoid_channel4/solenoid_P: D5.1 (K), F5.2, J8.1, J8.2, LED6.2 (A)
/solenoid_channel5/solenoid_N: D6.2 (A), J11.1, J11.2, Q6.5 (D), Q6.6 (D), Q6.7 (D), Q6.8 (D), R13.1 (+)
/solenoid_channel5/solenoid_P: D6.1 (K), F6.2, J10.1, J10.2, LED7.2 (A)
/solenoid_channel6/solenoid_N: D7.2 (A), J13.1, J13.2, Q7.5 (D), Q7.6 (D), Q7.7 (D), Q7.8 (D), R15.1 (+)
/solenoid_channel6/solenoid_P: D7.1 (K), F7.2, J12.1, J12.2, LED8.2 (A)
/solenoid_channel7/solenoid_N: D8.2 (A), J15.1, J15.2, Q8.5 (D), Q8.6 (D), Q8.7 (D), Q8.8 (D), R17.1 (+)
/solenoid_channel7/solenoid_P: D8.1 (K), F8.2, J14.1, J14.2, LED9.2 (A)
/solenoid_channel8/solenoid_N: D9.2 (A), J17.1, J17.2, Q9.5 (D), Q9.6 (D), Q9.7 (D), Q9.8 (D), R19.1 (+)
/solenoid_channel8/solenoid_P: D9.1 (K), F9.2, J16.1, J16.2, LED10.2 (A)
/solenoid_channel9/solenoid_N: D10.2 (A), J19.1, J19.2, Q10.5 (D), Q10.6 (D), Q10.7 (D), Q10.8 (D), R21.1 (+)
/solenoid_channel9/solenoid_P: D10.1 (K), F10.2, J18.1, J18.2, LED11.2 (A)
/solenoid_channel10/solenoid_N: D11.2 (A), J21.1, J21.2, Q11.5 (D), Q11.6 (D), Q11.7 (D), Q11.8 (D), R23.1 (+)
/solenoid_channel10/solenoid_P: D11.1 (K), F11.2, J20.1, J20.2, LED12.2 (A)
GND: Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.1 (S), Q4.2 (S), Q4.3 (S), Q5.1 (S), Q5.2 (S), Q5.3 (S), Q6.1 (S), Q6.2 (S), Q6.3 (S), Q7.1 (S), Q7.2 (S), Q7.3 (S), Q8.1 (S), Q8.2 (S), Q8.3 (S), Q9.1 (S), Q9.2 (S), Q9.3 (S), Q10.1 (S), Q10.2 (S), Q10.3 (S), Q11.1 (S), Q11.2 (S), Q11.3 (S); also elsewhere on the board
unnamed: LED4.1 (K), R7.2 (-)
unnamed: LED5.1 (K), R9.2 (-)
unnamed: LED6.1 (K), R11.2 (-)
unnamed: LED7.1 (K), R13.2 (-)
unnamed: LED8.1 (K), R15.2 (-)
unnamed: LED9.1 (K), R17.2 (-)
unnamed: LED10.1 (K), R19.2 (-)
unnamed: LED11.1 (K), R21.2 (-)
unnamed: LED12.1 (K), R23.2 (-)
unnamed: Q3.4 (G), R6.2 (-)
unnamed: Q4.4 (G), R8.2 (-)
unnamed: Q5.4 (G), R10.2 (-)
unnamed: Q6.4 (G), R12.2 (-)
unnamed: Q7.4 (G), R14.2 (-)
unnamed: Q8.4 (G), R16.2 (-)
unnamed: Q9.4 (G), R18.2 (-)
unnamed: Q10.4 (G), R20.2 (-)
unnamed: Q11.4 (G), R22.2 (-)

Notes on the sheet:
I_Hold: 0.3A I_Trip: 0.6A V_Max: 60V

Parts:
C1: 330u; CP_Elec_10x10; LCSC C2895745
C2: 3.3n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C1738
C3: 180u; CP_Elec_6.3x5.8; LCSC C2943990
D2: SK34; D_SOD-123; LCSC C908230
L1: 68u; L_Bourns_SRP7028A_7.3x6.6mm; LCSC C2894721
NT1: NetTie_2; NetTie-2_SMD_Pad0.5mm
U1: XL1509-5.0; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C2902368

Connections:
/+24V: C1.1, C2.1, U1.1 (VIN); also elsewhere on the board
/VGATE: C3.1, L1.2, NT1.2; also elsewhere on the board
/dc_dc_psu/Feedback: NT1.1, U1.3 (FB)
GND: C1.2, C2.2, C3.2, D2.2 (A), U1.5 (GND), U1.6 (GND), U1.7 (GND), U1.8 (GND); also elsewhere on the board
unnamed: D2.1 (K), L1.1, U1.2 (OUT)

Notes on the sheet:
DC-DC buck converter 5.0V Output
24V input, Caps should be rated for 36v just in case.
5.0v Output at maximum 2A for configuration

Board: 4 copper layers, 229.0 x 48.5 mm, 126 parts (20 on the bottom side), 57 nets.
